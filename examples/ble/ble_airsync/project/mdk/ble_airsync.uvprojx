# Keil uVision project ble_airsync.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: template +hex
  AfterMake: ..\..\..\..\..\tools\bluex\image_tool_v2\disassemble.bat @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --bss_threshold=0
  c include: ..\..\app;..\..\config;..\..\usercode;..\..\..\..\..\include;..\..\..\..\..\platform\cmsis;..\..\..\..\..\platform\bluex\apollo\common;..\..\..\..\..\platform\bluex\apollo\typedef;..\..\..\..\..\platform\bluex\apollo\apollo00;..\..\..\..\..\platform\bluex\apollo\apollo00\driver_service;..\..\..\..\..\components\bluex\ble\common;..\..\..\..\..\components\bluex\ble\dbg;..\..\..\..\..\components\bluex\bxfs;..\..\..\..\..\components\bluex\ble\profiles;..\..\..\..\..\components\bluex\ble\controller;..\..\..\..\..\components\bluex\ble\controller\patch;..\..\..\..\..\components\bluex\ble\controller\driver;..\..\..\..\..\components\bluex\ble\controller\driver\reg;..\..\..\..\..\components\bluex\ble\controller\driver\rf18_6;..\..\..\..\..\components\bluex\fifo;..\..\..\..\..\components\bluex\shell;..\..\..\..\..\components\3rdparty\cm_backtrace;..\..\..\..\..\components\3rdparty\button;..\..\app\crc32;..\..\app\protobuf;..\..\app\wechat_example;..\..\app\aes-md5
  library: MicroLIB
  memory RVCT4: ROM 0x803000 size 0x40000
  memory RVCT9: RAM 0x100000 size 0x30000
  scatter file: ..\..\..\..\..\components\bluex\ble\controller\fw_usr.txt
  link misc: --diag_suppress=L6314,L6329
..\..\..\..\..\components\bluex\ble\controller\rom_syms_armcc.txt  --datacompressor=off
  group bx/core
    ../../app/: main.c startup_apollo00_ble.s
    ../../../../../kernel/: bx_kernel.c bx_kernel_timer.c
  group bx/ble
    ../../../../../components/bluex/ble/controller/: ble_stack.c rwip.c rf_apollo.c nvds_task.c ecc_p256.c lld_sleep.c nvds_in_ram.c prf.c prf_utils.c rwble.c
    ../../../../../components/bluex/ble/common/: queued_async_framework.c bx_ring_queue.c
    ../../../../../components/bluex/ble/controller/driver/: app_dmac.c app_dmac_wrapper.c app_gpio.c app_hwecc.c app_hwecc_wrapper.c app_qspi.c app_qspi_wrapper.c app_rtc_wrapper.c arch_init.c clk_gate.c flash_base.c flash_cache.c flash_integration.c flash_wrapper.c io_ctrl.c jump_table.c modem.c patch.c periph_lock.c periph_mngt.c periph_recovery.c pshare.c rc_calib.c rf_reg_settings_apollo_00.c rst_gen.c sys_sleep.c sys_sleep_ram.c sysctrl.c true_random.c
    ../../../../../components/bluex/ble/controller/patch/: adv_int_patch.c adv_report_patch.c lld_evt_schedule_patch.c lld_pdu_tx_flush_list_patch.c lld_scan_stop.c lld_slave_instant_patch.c llm_end_evt_defer_patch.c llm_util_chk_tst_mode_patch.c llm_util_gen_pattern_tx_patch.c prog_latency_patch.c rc32k_patch.c scan_adv_rx_threshold_patch.c scan_timeout_patch.c set_adv_payload_31Byte_patch.c slave_finetimecnt_patch.c slave_latency_patch.c smpc_construct_id_addr_type_patch.c task_id_patch.c adv_report_patch_asm.s lld_pdu_tx_flush_list_patch_asm.s lld_scan_stop.s lld_slave_instant_patch_asm.s rc32k_patch_asm.s slave_finetimecnt_patch_asm.s smpc_construct_id_addr_type_patch_asm.s task_id_patch_asm.s llc_version_patch.c llc_version_patch.s
    ../../../../../components/bluex/bxfs/: bxfs.c bxfs_write_cache.c static_buffer.c
    ../../../../../components/bluex/ble/controller/driver/rf18_6/: adc_integration.c app_adc.c app_adc_utils.c refresh_rf_param_with_ro.c rf_temp_adjust.c
  group bx/log
    ../../../../../components/bluex/shell/: nr_micro_shell.c ansi_port.c ansi.c bx_shell.c bxsh_uart.c
    ../../../../../components/bluex/ble/dbg/: bx_dbg.c SEGGER_RTT.c SEGGER_RTT_printf.c bx_dbg_asm.s
  group bx/drivers
    ../../../../../platform/bluex/apollo/apollo00/driver_service/: bx_drv_adc.c bx_drv_gpio.c bx_drv_iic.c bx_drv_io_mux.c bx_drv_pwm.c bx_drv_spim.c bx_drv_tim.c bx_drv_uart.c bx_drv_wdt.c bx_pm.c bx_service.c bx_service_adc.c bx_service_gpio.c bx_service_iic.c bx_service_pwm.c bx_service_spi.c bx_service_tim.c bx_service_uart.c bx_service_wdt.c
    ../../../../../components/bluex/ble/controller/driver/: bx_drv_ble.c
  group components
    ../../../../../components/bluex/fifo/: bx_fifo.c
  group user/profiles
    ../../../../../components/bluex/ble/profiles/: diss.c diss_task.c bxotas.c bxotas_task.c
    ../../usercode/: user_profile.c user_profile_task.c
  group user/service
    ../../usercode/: user_service_ble.c user_service_button.c
  group user/app
    ../../app/: user_app.c user_ble.c user_ble_task.c user_ble_profile.c
    ../../usercode/: user_common_api.c user_common_api.h
  group user/drivers
    ../../../../../components/3rdparty/button/: flexible_button.c
  group cfg
    ../../config/: bx_config.h bx_sys_config.h bx_pcb_config.h bx_app_config.h bx_ip_config.h bx_sdk3_config.h
  group airsync
    ../../app/aes-md5/: aes.c md5.c
    ../../app/crc32/: crc32.c
    ../../app/protobuf/: epb.c epb_MmBp.c
    ../../app/wechat_example/: ble_wechat_util.c pb_example.c crc32_example.c
target bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: bootloader.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\app\inc;..\..\..\..\platform\cmsis;..\..\..\..\platform\bluex\apollo\common;..\..\..\..\platform\bluex\apollo\apollo00\system
  memory RVCT4: ROM 0x803000 size 0x40000
  memory RVCT9: RAM 0x100000 size 0x30000
