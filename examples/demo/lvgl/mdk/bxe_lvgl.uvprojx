# Keil uVision project bxe_lvgl.uvprojx, settings and files
target template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: template +hex
  AfterMake: ..\..\..\..\tools\bluex\image_tool_v2\disassemble.bat @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --bss_threshold=0
  c include: ..\..\..\..\include;..\..\..\..\platform\cmsis;..\..\..\..\platform\bluex\apollo\common;..\..\..\..\platform\bluex\apollo\typedef;..\..\..\..\platform\bluex\apollo\apollo00;..\..\..\..\platform\bluex\apollo\apollo00\driver_service;..\..\..\..\components\bluex\ble\common;..\..\..\..\components\bluex\ble\dbg;..\..\..\..\components\bluex\bxfs;..\..\..\..\components\bluex\ble\profiles;..\..\..\..\components\bluex\ble\controller;..\..\..\..\components\bluex\ble\controller\patch;..\..\..\..\components\bluex\ble\controller\driver;..\..\..\..\components\bluex\ble\controller\driver\reg;..\..\..\..\components\bluex\fifo;..\code;..\config;..\..\..\..\components\3rdparty\cm_backtrace;..\code\profile;..\..\..\..\components\bluex\ble\controller\driver\rf_setting;..\code\lvgl;..\code\lvgl\examples\porting;..\code\lvgl\examples
  library: MicroLIB
  memory RVCT4: ROM 0x803000 size 0x40000
  memory RVCT9: RAM 0x100000 size 0x30000
  scatter file: ..\config\user_link.txt
  link misc: --diag_suppress=L6314,L6329
..\..\..\..\components\bluex\ble\controller\rom_syms_armcc.txt  --datacompressor=off
  group bx/core
    ../code/: main.c startup_apollo00_ble.s
    ../../../../kernel/: bx_kernel.c bx_kernel_timer.c
  group bx/ble
    ../../../../components/bluex/ble/controller/: ble_stack.c rwip.c rf_apollo.c nvds_task.c ecc_p256.c lld_sleep.c nvds_in_ram.c rwble.c
    ../../../../components/bluex/ble/controller/driver/: app_dmac.c app_dmac_wrapper.c app_gpio.c app_hwecc.c app_hwecc_wrapper.c app_qspi.c app_qspi_wrapper.c arch_init.c clk_gate.c flash_base.c flash_cache.c flash_integration.c flash_wrapper.c io_ctrl.c jump_table.c modem.c patch.c periph_lock.c periph_mngt.c periph_recovery.c pshare.c rc_calib.c rf_reg_settings_apollo_00.c rst_gen.c sys_sleep.c sys_sleep_ram.c sysctrl.c true_random.c
    ../../../../components/bluex/ble/controller/patch/: adv_int_patch.c adv_report_patch.c lld_evt_schedule_patch.c lld_pdu_tx_flush_list_patch.c lld_scan_stop.c lld_slave_instant_patch.c llm_end_evt_defer_patch.c llm_util_chk_tst_mode_patch.c llm_util_gen_pattern_tx_patch.c prog_latency_patch.c rc32k_patch.c scan_adv_rx_threshold_patch.c scan_timeout_patch.c set_adv_payload_31Byte_patch.c slave_finetimecnt_patch.c slave_latency_patch.c smpc_construct_id_addr_type_patch.c task_id_patch.c adv_report_patch_asm.s lld_pdu_tx_flush_list_patch_asm.s lld_scan_stop_patch_asm.s lld_slave_instant_patch_asm.s rc32k_patch_asm.s slave_finetimecnt_patch_asm.s smpc_construct_id_addr_type_patch_asm.s task_id_patch_asm.s llc_version_patch.c llc_version_patch_asm.s
    ../../../../components/bluex/bxfs/: bxfs.c bxfs_write_cache.c static_buffer.c
    ../../../../components/bluex/ble/controller/driver/rf_setting/: adc_integration.c app_adc.c app_adc_utils.c refresh_rf_param_with_ro.c rf_power_set.c rf_temp_adjust.c rf_battery_adjust.c rf_power_exchange.c
  group bx/log
    ../../../../components/bluex/ble/dbg/: bx_dbg.c SEGGER_RTT.c bx_dbg_asm.s
  group bx/drivers
    ../../../../platform/bluex/apollo/apollo00/driver_service/: bx_pm.c bxd_gpio.c bxd_iic.c bxd_io_mux.c
  group user/profiles
    ../code/profile/: prf.c prf_utils.c diss.c diss_task.c app_dis.c
  group user/service
    ../code/: user_service_display_320380.c us_tp.c
  group user/app
    ../code/: app.c ble.c bx_apollo00_it.c
    ../code/lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
    ../code/lvgl/examples/get_started/: lv_example_get_started_1.c
  group cfg
    ../config/: bx_config.h bx_sys_config.h bx_pcb_config.h bx_app_config.h bx_ip_config.h bx_sdk3_config.h rf_power_set.h
  group lvgl
    ../code/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../code/lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../code/lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../code/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../code/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../code/lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../code/lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
target bootloader (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: bootloader.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\code\inc;..\..\..\..\platform\cmsis;..\..\..\..\platform\bluex\apollo\common;..\..\..\..\platform\bluex\apollo\apollo00\system
  memory RVCT4: ROM 0x803000 size 0x40000
  memory RVCT9: RAM 0x100000 size 0x30000
