# Keil uVision project mpu9250.uvprojx, settings and files
target template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: template +hex
  AfterMake: ..\..\..\..\tools\bluex\image_tool_v2\disassemble.bat @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,QN_902X,EMPL_TARGET_BX,MPU9250,EMPL,MPL_LOG_NDEBUG=1
  c misc: --bss_threshold=0
  c include: ..\..\..\..\include;..\..\..\..\platform\cmsis;..\..\..\..\platform\bluex\apollo\common;..\..\..\..\platform\bluex\apollo\typedef;..\..\..\..\platform\bluex\apollo\apollo00;..\..\..\..\platform\bluex\apollo\apollo00\driver_service;..\..\..\..\components\bluex\ble\common;..\..\..\..\components\bluex\ble\dbg;..\..\..\..\components\bluex\bxfs;..\..\..\..\components\bluex\ble\profiles;..\..\..\..\components\bluex\ble\controller;..\..\..\..\components\bluex\ble\controller\patch;..\..\..\..\components\bluex\ble\controller\driver;..\..\..\..\components\bluex\ble\controller\driver\reg;..\..\..\..\components\bluex\ble\controller\driver\rf_setting;..\..\..\..\components\bluex\fifo;..\config;..\..\..\..\components\3rdparty\cm_backtrace;..\code\profile;..\code;..\DMP\driver\eMPL;..\DMP\driver\include;..\DMP\driver\stm32L;..\DMP\eMPL-hal;..\DMP\mllite;..\DMP\mpl;..\MPU9250
  library: MicroLIB
  memory RVCT4: ROM 0x803000 size 0x40000
  memory RVCT9: RAM 0x100000 size 0x30000
  scatter file: ..\config\user_link.txt
  link misc: --diag_suppress=L6314,L6329
..\..\..\..\components\bluex\ble\controller\rom_syms_armcc.txt  --datacompressor=off
  group bx/core
    ../code/: main.c startup_apollo00_ble.s
    ../../../../kernel/: bx_kernel.c bx_kernel_timer.c
  group bx/ble
    ../../../../components/bluex/ble/controller/: ble_stack.c rwip.c rf_apollo.c nvds_task.c ecc_p256.c lld_sleep.c nvds_in_ram.c rwble.c
    ../../../../components/bluex/ble/controller/driver/: app_dmac.c app_dmac_wrapper.c app_gpio.c app_hwecc.c app_hwecc_wrapper.c app_qspi.c app_qspi_wrapper.c arch_init.c clk_gate.c flash_base.c flash_cache.c flash_integration.c flash_wrapper.c io_ctrl.c jump_table.c modem.c patch.c periph_lock.c periph_mngt.c periph_recovery.c pshare.c rc_calib.c rf_reg_settings_apollo_00.c rst_gen.c sys_sleep.c sys_sleep_ram.c sysctrl.c true_random.c
    ../../../../components/bluex/ble/controller/patch/: adv_int_patch.c adv_report_patch.c lld_evt_schedule_patch.c lld_pdu_tx_flush_list_patch.c lld_scan_stop.c lld_slave_instant_patch.c llm_end_evt_defer_patch.c llm_util_chk_tst_mode_patch.c llm_util_gen_pattern_tx_patch.c prog_latency_patch.c rc32k_patch.c scan_adv_rx_threshold_patch.c scan_timeout_patch.c set_adv_payload_31Byte_patch.c slave_finetimecnt_patch.c slave_latency_patch.c smpc_construct_id_addr_type_patch.c task_id_patch.c adv_report_patch_asm.s lld_pdu_tx_flush_list_patch_asm.s lld_scan_stop_patch_asm.s lld_slave_instant_patch_asm.s rc32k_patch_asm.s slave_finetimecnt_patch_asm.s smpc_construct_id_addr_type_patch_asm.s task_id_patch_asm.s llc_version_patch.c llc_version_patch_asm.s
    ../../../../components/bluex/bxfs/: bxfs.c bxfs_write_cache.c static_buffer.c
    ../../../../components/bluex/ble/controller/driver/rf_setting/: adc_integration.c app_adc.c app_adc_utils.c refresh_rf_param_with_ro.c rf_battery_adjust.c rf_power_exchange.c rf_power_set.c rf_temp_adjust.c
  group bx/log
    ../../../../components/bluex/ble/dbg/: bx_dbg.c SEGGER_RTT.c bx_dbg_asm.s
  group bx/drivers
    ../../../../platform/bluex/apollo/apollo00/driver_service/: bx_pm.c bxd_iic.c bxd_io_mux.c bxd_gpio.c
  group user/profiles
    ../code/profile/: prf.c prf_utils.c diss.c diss_task.c app_dis.c
  group user/drivers
    ../code/: mpu9250_iic.c
  group user/app
    ../code/: app.c ble.c bx_apollo00_it.c
  group cfg
    ../config/: bx_config.h bx_sys_config.h bx_pcb_config.h bx_app_config.h bx_ip_config.h bx_sdk3_config.h rf_power_set.h rwapp_config.h
  group dmp
    ../DMP/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../DMP/eMPL-hal/: eMPL_outputs.c
    ../DMP/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../DMP/mpl/: libmpllib.lib
  group mpu9250
    ../MPU9250/: mpu9250.c
target bootloader (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: bootloader.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\code\inc;..\..\..\..\platform\cmsis;..\..\..\..\platform\bluex\apollo\common;..\..\..\..\platform\bluex\apollo\apollo00\system
  memory RVCT4: ROM 0x803000 size 0x40000
  memory RVCT9: RAM 0x100000 size 0x30000
