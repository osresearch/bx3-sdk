# Keil uVision project uart_shell.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: template +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\app\inc;..\..\..\..\..\platform\cmsis;..\..\..\..\..\platform\bluex\apollo\common;..\..\..\..\..\platform\bluex\apollo\apollo00\system;..\..\..\..\..\platform\bluex\apollo\apollo00;..\..\usercode;..\..\..\..\..\components\bluex\shell;..\..\..\..\..\components\3rdparty\nr_micro_shell\inc;..\..\..\..\..\components\bluex\log;..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x803000 size 0x40000
  memory RVCT9: RAM 0x100000 size 0x30000
  group app
    ../../app/src/: main.c uart_shell_demo.c
  group startup
    ../../../../../platform/bluex/apollo/apollo00/system/: startup_apollo00.s
  group bx/shell
    ../../../../../components/bluex/shell/: shell_api.c uart_api.c ansi.c ansi_port.c nr_micro_shell.c
target bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: bootloader.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\app\inc;..\..\..\..\platform\cmsis;..\..\..\..\platform\bluex\apollo\common;..\..\..\..\platform\bluex\apollo\apollo00\system
  memory RVCT4: ROM 0x803000 size 0x40000
  memory RVCT9: RAM 0x100000 size 0x30000
